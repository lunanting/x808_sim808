# Keil uVision project x808模块.uvproj, settings and files
target x808模块 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: x808模块 +hex
  AfterMake: fromelf.exe --bin -o./Object/x808模块.bin ./Object/x808模块.axf
  AfterMake: fromelf.exe --i32 -o./Object/x808模块.hex ./Object/x808模块.axf
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --c99
  c include: .\App;.\App\projectCode;.\StdPeriph_Driver\inc;.\System;.\CMSIS;.\GPS_GPRS
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group StartUp
    ./StartUp/: RTX_Conf_CM.c startup_stm32f10x_md.s
  group Driver
    ./StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group System
    ./System/: function.c pack.c stm32f10x_it.c main.c module.c
  group App
    ./App/: app_config.c app_plug.c application.c task_list.c app.h
    ./App/projectCode/: app_lib.c
  group GPS_GPRS
    ./GPS_GPRS/: gps_gprs.c gps_gprs_lib.c gps_gprs.h x808模块驱动说明.txt
  group ReadMe
    ./ReadMe/: readme.txt
